# Keil uVision project line_follower.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: line_follower
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\user\inc;..\Project;.\Lib\common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c
    ./: main.c
    ./Lib/common/: stm32f10x_it.c
    ./Lib/user/src/: user_delay.c
